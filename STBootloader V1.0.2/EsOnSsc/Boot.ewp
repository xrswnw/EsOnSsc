# IAR project Boot.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; _ANYID_STM32F4_; _ANYID_HSE12P00_; _ANYID_BOOT_; _ANYID_R542A_
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Device\ST\STM32F4xx\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\STM32F4xx_StdPeriph_Driver\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Boot.hex
  ILINK.IlinkOutputFile: M345.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Build (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; _ANYID_STM32F4_; _ANYID_M345_; _ANYID_HSE13P56_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Device\ST\STM32F4xx\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\CMSIS\Include; E:\AnyID\AnyID_Embedded\V1.1.0\STM32F4_lib_V1.0.2\STM32F4xx_StdPeriph_Driver\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc
  OBJCOPY.OOCOutputFile: M345.hex
  ILINK.IlinkIcfFile: E:\AnyID\HFReader\software\M345A\EWARMv6\stm32f4xx_flash.icf
  group CMSIS
    ../../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARMv6
    ../../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s
  group Main
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c
  group StdPeriph_Driver
    ../../../../../AnyID_Embedded/V1.1.0/STM32F4_lib_V1.0.2/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ../src/: AnyID_Boot_FRam.c AnyID_Boot_FRam_HL.c AnyID_Boot_Lora.c AnyID_Boot_Lora_HL.c AnyID_Boot_R485.c AnyID_Boot_R485_HL.c AnyID_Boot_SysCfg.c AnyID_Boot_SysTick_HL.c AnyID_Boot_Tcp232.c AnyID_Boot_Tcp232_HL.c AnyID_Boot_Uart.c AnyID_Boot_Uart_HL.c AnyID_FRam.c AnyID_Uart_Receive.c
    ../../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
